Commit message: remove world link

File: prbt_robot_support/urdf/prbt.urdf (robot description, URDF)
Before this commit: robot prbt, 10 links, 9 joints
Links:
- removed link world
Joints:
- removed joint base_link_world_joint
